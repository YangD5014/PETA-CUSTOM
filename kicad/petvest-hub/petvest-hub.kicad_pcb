# Repository YangD5014/PETA-CUSTOM

File README.md:

# PETA CUSTOM 🐕

**基于多传感器的宠物智能服装方案** — 6 轴姿态捕捉 · 心率血氧 · GNSS 定位 · I2S 语音交互 · OLED 显示,一体化 KiCad 10 硬件设计。

| | |
|---|---|
| **主控** | ESP32-S3-WROOM-1-N8R8(WiFi + BLE + 原生 USB) |
| **姿态** | 6× LSM6DS3TR-C 六轴 IMU(分布式卫星节点) |
| **健康** | MAX30102 心率血氧探头 + MAX17048 电量计 |
| **定位** | GNSS 模块接口(NEO-6M / ATGM336H 级) |
| **语音** | INMP441 I2S 麦克风 + MAX98357A D类功放 |
| **显示** | 0.96" SSD1306 OLED |
| **电源** | 1S 4000mAh 锂电 · TP4056 1A 充电 · TPS63061 buck-boost |
| **续航** | ≥18h(全天在线约 25h,休眠策略 40h+) |
| **工具链** | KiCad 10 · 原理图/PCB/3D 全流程脚本化生成 |

---

## 1. 项目背景

运动量不足、异常行为与走失,是城市宠物犬的三大痛点。市面上的"宠物智能项圈"只能记录活动量,
无法回答更专业的问题:

- **姿态与步态**:跛行、关节炎早期、术后康复评估,需要关节级别的运动学数据;
- **生理状态**:应激、中暑、疼痛会反映在心率与呼吸模式上;
- **位置安全**:遛狗脱离视线后的实时定位。

PETA CUSTOM 采用**服装形态**而非项圈形态:IMU 传感器沿犬体脊柱与四肢根部分布式布置
(见 [穿戴位置示意](docs/img/dog-placement.svg)),才能获得躯干/四肢分段姿态——这是单一项圈
设备在物理上无法实现的。主板(Hub)集成电源、主控、语音与显示,通过软排线连接 6 个缝在服装
上的 IMU 卫星节点,整机重量与柔性针对犬类穿戴优化。

> ⚠ 本仓库目前为**硬件 v1.0 工程阶段**:原理图/PCB/3D/外壳已闭环并通过机器校验,
> 尚未打样。欢迎 issue 交流。

## 2. 系统架构

```
                      ┌────────── 1S 4000mAh 锂电(带PCM保护板) ──────────┐
                      │                                                  │
 USB-C 5V ──PTC 2A──TVS                                                  │
   │        └─► TP4056 1A ─┘─► 电源开关 ─► TPS63061 buck-boost ──► 3.3V/1.2A
   │                                                          │
 ESP32-S3-WROOM-1-N8R8 ◄── USB D+/D-(USBLC6 ESD) ── USB-C
   │ I2C0 ──┬── TCA9548A 8ch 复用 ──┬─ CH0..CH5 ──► 6× FPC ──► IMU 卫星节点 ×6
   │        │                      └─ CH7 ────► 预留扩展
   │        ├── MAX17048 电量计(0x36)
   │        ├── OLED SSD1306(0x3C, FPC-4)
   │        └── MAX30102 心率探头(FPC-6, 1.8V 板载 LDO)
   │ I2S1 ◄── INMP441 麦克风(卫星)   I2S0 ──► MAX98357A ──► 8Ω2W 喇叭
   │ UART1 ──► GNSS 模块(FPC-4)
   └ ADC ◄── 电池分压
```

**为什么是 Hub + 卫星节点?** 犬体是曲面,IMU 必须贴着颈/肩/髋/尾的皮肤。主板上只放
TCA9548A 复用器和 FPC 座,每颗 IMU 是独立的 14×10mm 小软板(含 2 颗缝纫孔),通过
≤30cm 软排线以 400kHz I2C 接入——同型号 IMU 的地址冲突也被复用器一并解决。

## 3. 功能特性

| 模块 | 方案 | 说明 |
|---|---|---|
| 姿态捕捉 | 6× LSM6DS3TR-C @ 104Hz | 颈/双肩/双髋/尾根分段姿态,支持步态与行为识别 |
| 心率血氧 | MAX30102 探头 | 1.8V 由主板供给,开漏 INT,建议贴耳廓内侧 |
| 定位 | GNSS 卫星模块 | 天线朝天布置于背带上方,远离主控天线 |
| 语音交互 | INMP441 + MAX98357A | 双 I2S 全双工;功放由电池直供保证音量,默认关断 |
| 显示 | SSD1306 0.96" | 胸前 OELD,与传感器共 I2C 总线 |
| 电源管理 | MAX17048 + ADC 双保险 | 精确 SOC + 分压兜底;充电/充满双 LED |
| 扩展 | TCA9548A CH7 预留 | 第 7 通道 FPC 座已布置,可加温度/气压等传感器 |

## 4. 仓库结构

```
peta-custom/
├── README.md
├── docs/
│   ├── img/                      # 全部展示图(3D截图/渲染图/示意图)
│   ├── schematic-svg/            # 主控板原理图(SVG 矢量)
│   ├── schematic-svg-node/       # IMU 节点原理图
│   ├── petvest-hub-schematic.pdf # 原理图 PDF(6 张分层图纸)
│   └── petvest-imu-node-schematic.pdf
├── kicad/
│   ├── petvest-hub/              # 主控 Hub 板 KiCad 10 工程
│   │   ├── petvest-hub.kicad_sch #   根原理图 + 6 张分图
│   │   ├── petvest-hub.kicad_pcb #   62×42mm 布局(70 封装已放置)
│   │   ├── petvest.kicad_sym     #   自定义符号库(MAX17048)
│   │   └── preview/              #   原理图 PDF + 3D 渲染图
│   └── petvest-imu-node/         # IMU 卫星节点工程(14×10mm, 打 6 片)
├── 3d/
│   ├── petvest-hub.glb / .step   # 整机 3D 模型(GLB 预览 / STEP 进 CAD)
│   ├── petvest-imu-node.glb / .step
│   ├── petvest-hub-外壳底壳.stl   # 3D 打印外壳(直接切片)
│   ├── petvest-hub-外壳盖板.stl
│   ├── viewer.html               # ★ 离线 3D 展示页(双击打开, 见 §5)
│   └── libs/                     # viewer 的本地 three.js 运行库
├── bom/
│   ├── bom-petvest-hub.csv       # 主板 BOM(含推荐型号)
│   ├── bom-petvest-imu-node.csv  # 节点 BOM(×6)
│   ├── netlist-petvest-hub.csv   # 64 网络连接表
│   └── pinmap-esp32s3.csv        # ESP32-S3 引脚分配表
└── tools/                        # 全流程生成脚本(改需求 → 重跑)
    ├── gen_schematic.py          #   原理图生成器
    ├── gen_pcb.py                #   PCB 布局生成器
    ├── gen_enclosure.py          #   外壳 STL 生成器
    ├── gen_viewer.py             #   3D 展示页生成器
    ├── gen_bom.py                #   BOM/引脚表导出
    └── check_netlist.py          #   网表交叉校验
```

## 5. 3D 展示页 ⭐

**在线版**(静态资源经 jsDelivr 分发):http://124.222.169.94:2000/KiCAD/3d/viewer-cdn.html

**离线版**:双击 [`3d/viewer.html`](3d/viewer.html) 即可在浏览器打开
(需保留 `3d/libs/` 目录;两者加载的都是 KiCad 导出的真实 GLB 模型,非示意图):

| 视图 | 内容 |
|---|---|
| 组装 | 外壳 + PCB + 全部元件的真实装配状态 |
| 爆炸图 | 盖板抬升 / PCB 悬浮,检查内部结构 |
| 仅 PCB | 裸板多角度检查 |
| 卫星节点 | 14×10mm IMU 节点(含缝纫孔) |

悬停任意元件显示**位号与中文说明**(数据来自 KiCad 工程)。

**装配视图**(外壳开口与板边接口一一对应):

**爆炸图**(盖板 / PCB / 底壳三层):

**仅 PCB**(俯视 + 等轴测):

**IMU 卫星节点**(14×10mm,Ø2.7 缝纫孔 ×2):

## 6. KiCad 光线追踪渲染

<table>
  <tr>
    <td></td>
  </tr>
  <tr>
    <td align="center"><sub>主控 Hub 板 · KiCad 10 光线追踪(元件 3D 模型来自官方库)</sub></td>
  </tr>
  <tr>
    <td></td>
  </tr>
</table>

## 7. 原理图

- 主控 Hub 板(6 张分图):[SVG 矢量](docs/schematic-svg/petvest-hub.svg) · [PDF](docs/petvest-hub-schematic.pdf)
- IMU 节点:[SVG](docs/schematic-svg-node/petvest-imu-node.svg) · [PDF](docs/petvest-imu-node-schematic.pdf)

## 8. 3D 打印外壳

底壳 66.2×46.2×10.7mm,所有开口与板边接口一一对应:
左壁 = USB-C / 电源开关拨嘴 / 电池出线 / 心率探头 FPC;顶壁 = 6×FPC 排线槽;
底壁 = 4×FPC 排线槽 + 织带缝合槽;右壁 = 2×织带缝合槽;盖板 = 4×M2.5 自攻柱 + 2×LED 透光孔。

打印建议:0.2mm 层厚 · 壁厚 ≥1.8mm(4 圈)· PETG 或 TPU;**切片时多实体请勾选"合并/Union"**。

## 9. 快速开始

```bash
# 打开硬件工程(KiCad 10)
open kicad/petvest-hub/petvest-hub.kicad_pro

# 查看 3D(双击或)
open 3d/viewer.html

# 修改需求后一键重建(原理图 → PCB → 外壳 → BOM → 展示页)
python3 tools/gen_schematic.py && python3 tools/gen_pcb.py
python3 tools/gen_enclosure.py && python3 tools/gen_bom.py && python3 tools/gen_viewer.py
```

生成器已内置校验:原理图导出网表与模型逐节点比对 PASS;PCB 生成含"原理图元件必须全部有封装"断言。

## 10. 路线图

- [x] v1.0 原理图(7 张分层图纸, 网表机器校验通过)
- [x] v1.0 PCB 布局(70 封装, 鼠线待布)
- [x] 3D 模型 + 打印外壳
- [x] 离线 3D 展示页
- [ ] 铜线布线 + DRC(下一版)
- [ ] MAX30102 心率探头小板(犬类 PPG 预研)
- [ ] 固件框架(ESP-IDF: 采样/融合/上报)
- [ ] 打样与犬类实测

## 11. 工程注意事项

1. **犬类心率**:毛发遮挡强,反射式 PPG 务必先做耳廓内侧信号质量预研;
2. **电池安全**:必须使用带 PCM 保护板的电芯(主板未画保护电路);
3. **天线**:ESP32 天线区净空 ≥8mm,GNSS 天线远离功放与 USB;
4. MAX17048/TP4056 封装 EP 尺寸请对照实际采购批次 datasheet 复核。

## KiCad design kicad/petvest-hub/petvest-hub.kicad_pcb

Notes on the sheet:
PetVest Hub: 各图纸间用全局标签连接 (I2C_SDA/I2C_SCL/I2S_*/IMU_INT*/GPS_*/USB_DP…)

Parts:
C1, C2: 10µF; C_0805_2012Metric
C3, C4, C5, C6: 22µF; C_0805_2012Metric
C7, C8, C9: 100nF; C_0603_1608Metric
D1: PESD5V0S1BA; D_SOD-323
D2: 红·充电中; LED_0603_1608Metric
D3: 绿·已充满; LED_0603_1608Metric
F1: 2A/9V; Fuse_1812_4532Metric
J1: USB-C 16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: 1S 4000mAh; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
L1: 1.5µH 3.5A; L_Bourns-SRN4018
R1, R2: 5.1k; R_0603_1608Metric
R3: 1.2k; R_0603_1608Metric
R4, R5: 1k; R_0603_1608Metric
R6, R7: 100k; R_0603_1608Metric
SW1: POWER; SW_SPDT_PCM12
TP1: 3V3; TestPoint_Pad_D1.5mm
TP2: GND; TestPoint_Pad_D1.5mm
TP3: BATT; TestPoint_Pad_D1.5mm
TP4: VBUS; TestPoint_Pad_D1.5mm
U1: USBLC6-2SC6; SOT-23-6
U2: TP4056; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm
U3: TPS63061; Texas_DRC0010J
U4: MAX17048; DFN-8-1EP_2x2mm_P0.5mm_EP0.9x1.3mm

Connections:
+BATT: C2.1, C8.1, J2.1, R6.1, SW1.1 (A), TP3.1, U2.5 (BAT), U4.1 (VDD)
I2C_SCL: U4.4 (SCL); also elsewhere on the board
I2C_SDA: U4.3 (SDA); also elsewhere on the board
NET_BATADC: C9.1, R6.2, R7.1; also elsewhere on the board
NET_CC1: J1.A5 (CC1), R1.1
NET_CHRG: D2.1 (K), U2.7 (~CHRG)
NET_L1: L1.1, U3.1 (L1)
NET_L2: L1.2, U3.10 (L2)
NET_LCHG_A: D2.2 (A), R4.2
NET_LSTD_A: D3.2 (A), R5.2
NET_PROG: R3.1, U2.2 (PROG)
NET_STDY: D3.1 (K), U2.6 (~STDBY)
NET_VAUX: C7.1, U3.6 (VAUX)
USB_DM: U1.3 (I/O2); also elsewhere on the board
USB_DM_C: J1.A7 (D-), J1.B7 (D-), U1.4 (I/O2)
USB_DP: U1.1 (I/O1); also elsewhere on the board
USB_DP_C: J1.A6 (D+), J1.B6 (D+), U1.6 (I/O1)
VBUS: D1.1 (A1), F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP4.1, U1.5 (VBUS)
VBUS_F: C1.1, F1.2, R4.1, R5.1, U2.4 (V_{CC}), U2.8 (CE)

Notes on the sheet:
USB-C: CC1/CC2 5.1k下拉声明默认5V供电; D+/D-经USBLC6 ESD后接ESP32-S3原生USB(IO19/20)
TP4056: R3=1.2k → 充电1A; TEMP接地禁用温度检测(电池包自带PCM); CE接VBUS_F=插USB即充
TPS63061: 2.9-4.5V输入→固定3.3V/1.2A; PS/SYNC=GND自动PFM; FB接VOUT
电源预算(18h续航目标, 1S 4000mAh≈14.8Wh): ESP32-S3 WiFi间歇上报 ~80mA | GNSS ~40mA | 6×IMU@104Hz ~5mA OLED ~12mA | 心率(占空比) ~3mA | 音频待机 ~1mA | 电量计/漏 ~1mA 合计~140-150mA → 18h需≥2700mAh; 4000mAh≈25h在线/40h+(休眠策略)

Parts:
C10: 10µF; C_0805_2012Metric
C11: 100nF; C_0603_1608Metric
C12: 1µF; C_0603_1608Metric
D4: 蓝·状态; LED_0603_1608Metric
J10: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
R8: 10k; R_0603_1608Metric
R9: 1k; R_0603_1608Metric
SW2: RESET; SW_SPST_SKQG_WithStem
SW3: BOOT; SW_SPST_SKQG_WithStem
TP5: RGB_DIN; TestPoint_Pad_D1.5mm
U10: ESP32-S3-WROOM-1-N8R8; ESP32-S3-WROOM-1

Connections:
DEBUG_RX: J10.3, U10.36 (RXD0)
DEBUG_TX: J10.2, U10.37 (TXD0)
GPS_RXD: U10.31 (IO38); also elsewhere on the board
GPS_TXD: U10.23 (IO21); also elsewhere on the board
HR_INT: U10.15 (IO3); also elsewhere on the board
I2C_SCL: U10.17 (IO9); also elsewhere on the board
I2C_SDA: U10.12 (IO8); also elsewhere on the board
I2S_AMP_BCLK: U10.18 (IO10); also elsewhere on the board
I2S_AMP_DIN: U10.7 (IO7); also elsewhere on the board
I2S_AMP_LRC: U10.19 (IO11); also elsewhere on the board
I2S_MIC_SCK: U10.5 (IO5); also elsewhere on the board
I2S_MIC_SD: U10.6 (IO6); also elsewhere on the board
I2S_MIC_WS: U10.4 (IO4); also elsewhere on the board
IMU_INT1: U10.21 (IO13); also elsewhere on the board
IMU_INT2: U10.22 (IO14); also elsewhere on the board
IMU_INT3: U10.8 (IO15); also elsewhere on the board
IMU_INT4: U10.9 (IO16); also elsewhere on the board
IMU_INT5: U10.10 (IO17); also elsewhere on the board
IMU_INT6: U10.11 (IO18); also elsewhere on the board
NET_AMPSD: U10.38 (IO2); also elsewhere on the board
NET_BATADC: U10.39 (IO1); also elsewhere on the board
NET_BOOT: SW3.1, U10.27 (IO0)
NET_EN: C12.1, R8.2, SW2.1, U10.3 (EN)
NET_LED47: R9.1, U10.24 (IO47)
NET_LED_A: D4.2 (A), R9.2
NET_MUXRST: U10.20 (IO12); also elsewhere on the board
RGB_DIN: TP5.1, U10.25 (IO48)
USB_DM: U10.13 (USB_D-); also elsewhere on the board
USB_DP: U10.14 (USB_D+); also elsewhere on the board

Notes on the sheet:
ESP32-S3-WROOM-1-N8R8 GPIO分配: IO0 BOOT键 | IO1 电池分压ADC | IO2 功放SD | IO3 心率INT IO4/5/6 I2S麦克风 WS/SCK/SD | IO7/10/11 I2S功放 DIN/BCLK/LRC IO8/9 I2C0 SDA/SCL | IO12 复用器RESET | IO13-18 IMU INT1-6 IO19/20=USB_D-/D+ | IO21→GPS_RX | IO38←GPS_TX | IO47 LED | IO48 RGB扩展 IO35-37(OctalPSRAM)/IO39-42(仅输入)/IO45-46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
⚠ 天线朝板边; 天线区及两侧≥8mm禁止铺铜走线; 底层勿布高速线

Parts:
C13: 100nF; C_0603_1608Metric
C14: 4.7µF; C_0603_1608Metric
J21, J22, J23, J24, J25, J26, J27: Conn_01x05; TE_84953-5_1x05-1MP_P1.0mm_Horizontal
R10, R11: 2.2k; R_0603_1608Metric
R12: 10k; R_0603_1608Metric
U20: TCA9548A; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
I2C_SCL: R11.1, U20.22 (SCL); also elsewhere on the board
I2C_SDA: R10.1, U20.23 (SDA); also elsewhere on the board
IMU1_SCL: J21.4, U20.5 (SC0)
IMU1_SDA: J21.3, U20.4 (SD0)
IMU2_SCL: J22.4, U20.7 (SC1)
IMU2_SDA: J22.3, U20.6 (SD1)
IMU3_SCL: J23.4, U20.9 (SC2)
IMU3_SDA: J23.3, U20.8 (SD2)
IMU4_SCL: J24.4, U20.11 (SC3)
IMU4_SDA: J24.3, U20.10 (SD3)
IMU5_SCL: J25.4, U20.14 (SC4)
IMU5_SDA: J25.3, U20.13 (SD4)
IMU6_SCL: J26.4, U20.16 (SC5)
IMU6_SDA: J26.3, U20.15 (SD5)
IMU_INT1: J21.5; also elsewhere on the board
IMU_INT2: J22.5; also elsewhere on the board
IMU_INT3: J23.5; also elsewhere on the board
IMU_INT4: J24.5; also elsewhere on the board
IMU_INT5: J25.5; also elsewhere on the board
IMU_INT6: J26.5; also elsewhere on the board
NET_MUXRST: R12.1, U20.3 (~RESET); also elsewhere on the board
SPARE_SCL: J27.4, U20.20 (SC7)
SPARE_SDA: J27.3, U20.19 (SD7)

Notes on the sheet:
IMU卫星节点 = LSM6DS3TR-C(LGA-14)+2颗电容, 详见 petvest-imu-node 工程 节点I2C地址0x6A(SA0=GND); 上拉电阻仅主控侧2.2k(通道导通时全总线连通) FPC-5P 1.0mm 线序: 1=3V3 2=GND 3=SDA 4=SCL 5=INT; 软排线≤30cm @400kHz

Parts:
C15: 1µF; C_0603_1608Metric
C16: 2.2µF; C_0603_1608Metric
J30: Conn_01x06; TE_84953-6_1x06-1MP_P1.0mm_Horizontal
R13: 10k; R_0603_1608Metric
U30: AP2112K-1.8; SOT-23-5

Connections:
+1V8: C16.1, J30.2, U30.5 (VOUT)
HR_INT: J30.6, R13.1; also elsewhere on the board
I2C_SCL: J30.5; also elsewhere on the board
I2C_SDA: J30.4; also elsewhere on the board

Notes on the sheet:
探头卫星板 = MAX30102(OLGA-14) + 100nF/4.7µF, 柔性耳夹或胸贴封装 探头引脚: VDD=1.8V(本板LDO经FPC供电) VLED+=3.3V INT=开漏(本板10k上拉) ⚠ 犬类毛发遮挡: 反射式PPG建议贴耳廓内侧/大腿内侧, 先验证信号质量再定型

Parts:
C17: 10µF; C_0805_2012Metric
C18: 1µF; C_0603_1608Metric
J40: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J41: Conn_01x06; TE_84953-6_1x06-1MP_P1.0mm_Horizontal
R14: 100k; R_0603_1608Metric
U40: MAX98357A; QFN-16-1EP_3x3mm_P0.5mm_EP1.45x1.45mm

Connections:
I2S_AMP_BCLK: U40.16 (BCLK); also elsewhere on the board
I2S_AMP_DIN: U40.1 (DIN); also elsewhere on the board
I2S_AMP_LRC: U40.14 (LRCLK); also elsewhere on the board
I2S_MIC_SCK: J41.4; also elsewhere on the board
I2S_MIC_SD: J41.3; also elsewhere on the board
I2S_MIC_WS: J41.5; also elsewhere on the board
NET_AMPSD: R14.1, U40.4 (~SD_MODE); also elsewhere on the board
NET_SPKN: J40.2, U40.10 (OUTN)
NET_SPKP: J40.1, U40.9 (OUTP)

Notes on the sheet:
功放VDD接VSW(开关后电池3.0-4.2V)→音量最大; SD_MODE 100k下拉=默认关断 GAIN_SLOT接地=12dB(量产前按喇叭灵敏度复核); 麦克风L/R接地=左声道 ⚠ 喇叭/麦克风开孔与3D打印外壳声学腔对齐, 加防水透声膜

Parts:
C19: 10µF; C_0805_2012Metric
J50, J51: Conn_01x04; TE_84953-4_1x04-1MP_P1.0mm_Horizontal

Connections:
GPS_RXD: J50.3; also elsewhere on the board
GPS_TXD: J50.4; also elsewhere on the board
I2C_SCL: J51.3; also elsewhere on the board
I2C_SDA: J51.4; also elsewhere on the board

Notes on the sheet:
GNSS: 引脚3=模块TXD→主控IO38(RX); 引脚4=模块RXD←主控IO21(TX); 需3.3V逻辑模块 天线面朝上, 远离ESP32天线/功放/USB; 犬背上方开窗对天线 OLED: SSD1306 128x64 I2C 0x3C, 挂I2C0直连(不经复用器), 位置=胸带正面

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